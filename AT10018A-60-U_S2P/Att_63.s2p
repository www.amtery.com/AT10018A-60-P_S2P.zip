#  HZ  S  DB  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNB40-4Port,1311601084101679,3.45
! Created: UTC 4/25/2025, 8:49:26 AM
! freq[Hz]  db:S11  ang:S11  db:S21  ang:S21  db:S12  ang:S12  db:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   1750 points, 100 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -65.10 dB at 110.2 MHz (marker M1); lowest = -72.0 dB at 17.52 GHz (marker M2)
!   lowest |S11| = -42.1 dB at 100 MHz (marker M3), VSWR 1.02, Z = 50.6 - j0.564 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -43.6 to -13.8 dB; largest |S21 - S12| = 2.5e-05
!   S11 on the Smith chart (normalised r, x): 100 MHz: 1.01, -0.01; 9.454 GHz: 0.71, +0.16; 13.89 GHz: 1.52, -0.28; 15.91 GHz: 0.59, -0.28; 18 GHz: 0.64, +0.38
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 MHz  -42.1  -65.1  -65.1  -43.6
! 110.2 MHz  -41.6  -65.1  -65.1  -43.2
! 284.2 MHz  -35.9  -65.2  -65.2  -36.3
! 478.7 MHz  -32.1  -65.2  -65.3  -32.4
! 1.042 GHz  -25.6  -65.5  -65.5  -26.1
! 1.973 GHz  -20.4  -65.8  -65.8  -21.4
! 3.088 GHz  -18.2  -66.2  -66.2  -20.0
! 4.368 GHz  -20.4  -66.4  -66.4  -23.1
! 5.36 GHz  -27.6  -66.7  -66.7  -29.6
! 5.719 GHz  -30.6  -66.9  -66.8  -28.3
! 6.067 GHz  -28.2  -67.1  -67.0  -25.2
! 6.619 GHz  -22.6  -67.3  -67.2  -21.3
! 7.254 GHz  -18.7  -67.6  -67.6  -18.6
! 9.055 GHz  -14.4  -68.4  -68.4  -16.3
! 9.454 GHz  -14.2  -68.6  -68.6  -16.5
! 11.44 GHz  -16.9  -69.1  -69.2  -20.1
! 12.04 GHz  -17.5  -69.4  -69.4  -20.0
! 13.89 GHz  -12.6  -70.2  -70.3  -14.9
! 15.02 GHz  -10.8  -70.7  -70.9  -13.8
! 15.91 GHz  -10.3  -71.7  -71.1  -14.0
! 17.52 GHz  -10.2  -72.0  -71.4  -14.5
! 18 GHz  -10.1  -71.4  -71.9  -14.3
